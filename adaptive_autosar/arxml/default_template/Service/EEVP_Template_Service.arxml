<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00049.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="c62f33cc-747f-4a84-a1f3-d41a82cc4785">
      <SHORT-NAME>ServiceDeployment</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="c7fba68e-eb0f-4a60-958e-34b3b7cb6748">
          <SHORT-NAME>Ipc</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4730edbc-ae32-4775-89f3-76b770c5292b">
          <SHORT-NAME>Someip</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="80c4a3bf-a4f6-4138-a4c6-6b70bedafe8d">
      <SHORT-NAME>ServiceInstance</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1f1c8c40-f955-4a7a-8ea8-a656ffba1f32">
          <SHORT-NAME>Endpoint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="505fa4de-86eb-4120-8390-e7645cff6d2e">
          <SHORT-NAME>Ipc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="43417451-e9e9-4247-b13a-3076c1db22cd">
              <SHORT-NAME>Consumer</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="f8be8af6-7701-4bf8-a60e-7f10ef8660db">
              <SHORT-NAME>Provider</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="e2f4288c-4168-4b93-adf5-cd9974d2d033">
          <SHORT-NAME>SdTimingConfig</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="815cf76b-c143-4cd0-a0e3-275c30ad821d">
              <SHORT-NAME>Client</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="f0e7b7ac-59dc-4c3b-a775-4240366d3f0c">
              <SHORT-NAME>Server</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="516973fc-ffda-4ff6-a4a1-2fba41df2d92">
              <SHORT-NAME>Subscription</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9d35ed01-dcee-435d-8e84-bea00cb0a0be">
          <SHORT-NAME>Someip</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="d7fd1a94-af27-46ba-a104-dc80e46e1bb6">
              <SHORT-NAME>Consumer</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="ba6bf8bd-2ba1-488a-8887-191220e900c5">
              <SHORT-NAME>Provider</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ada7792a-06c0-49ac-ad74-652b05089e17">
      <SHORT-NAME>ServiceInterface</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="f6da1751-f5ad-4dbe-b2ba-1b5b6c6607ab">
          <SHORT-NAME>ErrorDomain</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
