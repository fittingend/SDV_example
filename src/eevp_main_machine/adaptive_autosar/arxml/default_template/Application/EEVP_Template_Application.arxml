<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00049.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="15d34bdb-43c5-49dd-a484-acfd0c51f7da">
      <SHORT-NAME>Application</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="cd6ec693-deb3-49ec-b7d5-f6a7919f0259">
          <SHORT-NAME>DltConfig</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="87f74325-a89a-488c-aaff-dbc25f8cdc60">
          <SHORT-NAME>Executable</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="c7804087-03d1-4a6e-91d7-14b3e9d0ebe2">
          <SHORT-NAME>Manifest</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2c411a42-ecde-4475-9e81-7c3df4ff167f">
          <SHORT-NAME>Process</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="c2e7bd7b-730c-4501-9603-be73e02c821e">
          <SHORT-NAME>StartupConfig</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="b48a42b0-912a-4cec-ab85-f7b1fdf7c42a">
          <SHORT-NAME>SwComponent</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
